# IAR project QSFP28_PSM4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072RZ ST STM32L072RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L072xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: CMSIS; USER\Inc; FWlib\Inc; HARDWARE\LedDriver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: QSFP28_PSM4.hex
  ILINK.IlinkOutputFile: QSFP28_PSM4.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group CMSIS
    CMSIS/startup/: startup_stm32l072xx.s
    CMSIS/: system_stm32l0xx.c
  group FWlib
    FWlib/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c
  group HARDWARE
    HARDWARE/LedDriver/: led_driver.c
  group USER
    USER/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
